* {'lib': 'sf', 'VDD': 1.5, 'RLOAD': 500}
.lib /home/nataraj/projects/designmyic/cad/pdk/share/pdk/sky130B/libs.tech/ngspice/sky130.lib.spice sf
.include /home/nataraj/projects/designmyic/cad/cygnus/examples/test//tb_res_div.spice
