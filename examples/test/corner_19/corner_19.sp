* {'lib': 'tt', 'VDD': 1.8, 'RLOAD': 10000.0}
.lib /home/nataraj/projects/designmyic/cad/pdk/share/pdk/sky130B/libs.tech/ngspice/sky130.lib.spice tt
.include /home/nataraj/projects/designmyic/cad/cygnus/examples/test//tb_res_div.spice
