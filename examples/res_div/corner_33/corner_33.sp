* {'lib': 'ss', 'VDD': 2.1, 'RLOAD': 500}
.lib /home/nataraj/projects/designmyic/cad/pdk/share/pdk/sky130B/libs.tech/ngspice/sky130.lib.spice ss
.include /home/nataraj/projects/designmyic/cad/cygnus/examples/res_div//tb_res_div.spice
