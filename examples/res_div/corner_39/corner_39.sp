* {'lib': 'sf', 'VDD': 1.5, 'RLOAD': 10000.0}
.lib /home/nataraj/projects/designmyic/cad/pdk/share/pdk/sky130B/libs.tech/ngspice/sky130.lib.spice sf
.include /home/nataraj/projects/designmyic/cad/cygnus/examples/res_div//tb_res_div.spice
