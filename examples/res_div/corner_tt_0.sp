**Sample Corner Simulation File

.include res_div.spice
.lib /home/nataraj/projects/designmyic/cad/pdk/share/pdk/sky130B/libs.tech/ngspice/sky130.lib.spice tt

.control
write examples/test.raw
.endc
